# Keil uVision project usart.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8G1K08 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x03FF) IROM(0-0x1FF8) CLOCK(35000000)
  output: usart +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\USART;.\Driver\inc
  group start
    ./: STARTUP.A51
  group driver
    ./Driver/src/: STC8G_H_Delay.c STC8G_H_GPIO.c STC8G_H_NVIC.c STC8G_H_UART.c
  group isr
    ./Driver/isr/: STC8G_H_UART_Isr.c
  group app
    ./: main.c
